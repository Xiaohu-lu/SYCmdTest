# Keil uVision project AS578_InfoSec_Alg_Example.uvprojx, settings and files
target AS578_InfoSec_Alg_Example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: AS578_InfoSec_Alg_Example
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: AS578
  c include: ..\..\..\Libraries\CMSIS\CM3;..\..\..\Libraries\HAL;..\..\..\Libraries\Startup;..\..\..\Libraries\Startup\KEIL;..\Source;..\..\..\Libraries\HAL\USB;..\..\..\Libraries\HAL\ISAL;..\..\..\Libraries\HAL\FPAL;..\..\..\Libraries\HAL\ISAL\SM;C:\Keil\ARM\CMSIS\Include;..\Source\FreeRTOS\include;..\Source\FreeRTOS\portable;..\Source\ModuleDirvers;..\Source\platform;..\Source\hal;..\Source\hardware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\Libraries\LCF\KEIL\SY09_FwLib.sct
  link misc: --entry Reset_Handler
  group CMSIS Files
    ../../../Libraries/CMSIS/CM3/: core_cm3.c core_cm3.h
  group Startup Files
    ../../../Libraries/Startup/: system_SY09.c
    ../../../Libraries/Startup/KEIL/: startup_SY09.s
  group HAL Files
    ../../../Libraries/HAL/: Bvd.c Bvd.h Crc.c Crc.h Dma.c Dma.h Efc.c Efc.h Gpio.c Gpio.h I2c.c I2c.h Iso7816.c Iso7816.h Locsc.c Locsc.h Retarget.c Serial.c Sci.c Sci.h Scm.c Scm.h SFlash.h Spi.c Spi.h Sqi.c Sqi.h Ssi.c Ssi.h Swps.c Swps.h SY09.h SY09_Device.h SY09_Regs.c Timer.c Timer.h Uart.c Uart.h Vpwm.c Vpwm.h XFlash.h KFlash.c KFlash.h Otp.c Otp.h SFlashBk.c SFlashMap.c XFlashBk.c XFlashMap.c
  group Application Files
    ../Source/: main.c SYglobal.h safecmd.c operationkey.c
  group USB Driver Files
    ../../../Libraries/HAL/USB/: bulkitem.c bulkusb.c bulkusb.h ctrlitem.c CtrlItem.h ctrlusb.c CtrlUsb.h Usb.h UsbBase.c UsbBase.h usbcont.h USBProtocol.c USBProtocol.h
  group Fingerprint Alg Lib
    ../../../Libraries/HAL/FPAL/: SYFP.h FP_LIB.lib
  group Info Security Alg Lib
    ../../../Libraries/HAL/ISAL/: Alg.h AES.h AES_LIB.lib Des.h DES_LIB.lib ECC.h ECC_LIB.lib HardEcc.h Md5.h RSA.h RSA_LIB.lib sha-1.h sha-256.h Trng.h TRNG_LIB.lib SM1.h SM4.h SM2.h SM3.h AlgInit.h sha-512.h SSF33.h SSF33_LIB.lib MD5_LIB.lib SHA1_LIB.lib SHA256_LIB.lib SHA512_LIB.lib
    ../../../Libraries/HAL/ISAL/SM/: SM1_LIB.lib SM2_LIB.lib SM3_LIB.lib SM4_LIB.lib
  group hardware
    ../Source/hardware/: sy09_uart0.c
  group ModuleDrivers
    ../Source/ModuleDirvers/: ring_buffer.c
  group FreeRTOS/src
    ../Source/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../Source/FreeRTOS/portable/: heap_4.c port.c
  group sy
    ../Source/sy/: sy_command.c
  group hal
    ../Source/hal/: sy_uart_hal.c
  group platform
    ../Source/platform/: platform_Semphore.c
  group RTOS/Task
    ../Source/: led_task.c
software components: CMSIS:CORE 5.6.0
